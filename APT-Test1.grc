options:
  parameters:
    author: augus
    generate_options: qt_gui
    id: NFM_Test2
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: agc_gain
  id: variable_qtgui_range
  parameters:
    label: AGC Gain
    orient: Qt.Horizontal
    rangeType: int
    start: '1'
    step: '1'
    stop: '100'
    value: '1'
  states: {}
- name: agc_ref
  id: variable_qtgui_range
  parameters:
    label: AGC Reference
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '1'
    value: '1'
  states: {}
- name: cutoff_freq
  id: variable_qtgui_range
  parameters:
    label: Cutoff Frequency
    orient: Qt.Horizontal
    rangeType: int
    start: '4000'
    step: '100'
    stop: '80000'
    value: '42000'
  states: {}
- name: on_off_switch
  id: variable_qtgui_chooser
  parameters:
    label: Audio On/Off
    label0: 'ON'
    label1: 'OFF'
    num_opts: '2'
    option0: '0'
    option1: '1'
    type: int
    value: '0'
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    label: RF Gain
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '76'
    value: '50'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2400000'
  states: {}
- name: satellite_selector
  id: variable_qtgui_chooser
  parameters:
    label: 'Target Satellite:'
    label0: NOAA 15
    label1: NOAA 18
    label2: NOAA 19
    label3: Marine Weather
    num_opts: '4'
    option0: '137620000'
    option1: '137912500'
    option2: '137100000'
    option3: '162550000'
    type: int
    value: '137620000'
  states: {}
- name: transition_width
  id: variable_qtgui_range
  parameters:
    label: Transition Width
    orient: Qt.Horizontal
    rangeType: int
    start: '10000'
    step: '1000'
    stop: '500000'
    value: '26000'
  states: {}
- name: tuning
  id: variable_qtgui_range
  parameters:
    label: Frequency Shift
    orient: Qt.Horizontal
    rangeType: int
    start: '-100000'
    step: '1000'
    stop: '100000'
    value: '0'
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    label: Volume
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '1'
    value: '0.4'
    widget: dial
  states: {}
- name: zoom
  id: variable_qtgui_range
  parameters:
    label: Zoom
    min_len: '100'
    orient: Qt.Vertical
    start: '0'
    step: '0.01'
    stop: '1'
    value: '1'
    widget: slider
  states: {}
- name: analog_agc2_xx_0
  id: analog_agc2_xx
  parameters:
    attack_rate: '1e-1'
    decay_rate: '1e-2'
    gain: agc_gain
    max_gain: '65536'
    reference: agc_ref
    type: float
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: '48000'
    max_dev: 5e3
    quad_rate: '480000'
    tau: '75e-6'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    ok_to_block: 'False'
    samp_rate: '48000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: '0'
    num_inputs: '1'
    num_outputs: '2'
    output_index: on_off_switch
    type: float
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample: '8'
    file: C:\Users\augus\Documents\DS\Radio\NOAA-18-20211003-1936.wav
    samp_rate: '48000'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: cutoff_freq
    decim: '1'
    gain: '1'
    interp: '10'
    samp_rate: '480000'
    type: fir_filter_ccf
    width: transition_width
    win: firdes.WIN_BLACKMAN
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate * zoom
    fc: satellite_selector + tuning
    fftsize: '1024'
    showrf: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '10'
    interp: '2'
    taps: ''
    type: ccc
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    ant0: RX
    bb_gain0: '20'
    freq0: satellite_selector + tuning
    gain0: rf_gain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {}

connections:
- [analog_agc2_xx_0, '0', blocks_multiply_const_vxx_0, '0']
- [analog_nbfm_rx_0, '0', analog_agc2_xx_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_selector_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_wavfile_sink_0, '0']
- [blocks_selector_0, '0', audio_sink_0, '0']
- [blocks_selector_0, '1', blocks_null_sink_0, '0']
- [low_pass_filter_0, '0', analog_nbfm_rx_0, '0']
- [rational_resampler_xxx_1, '0', low_pass_filter_0, '0']
- [rtlsdr_source_0, '0', qtgui_sink_x_0, '0']
- [rtlsdr_source_0, '0', rational_resampler_xxx_1, '0']

metadata:
  file_format: 1
